# Keil uVision project iSO-STM32.uvproj, settings and files
target MaintainBox (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MaintainBox +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\SysTick;..\..\User\input;..\..\User\i2c_ee;..\..\User\sht10;..\..\User\usart1;..\..\User\uIP_APP;..\..\User\uIP_enc28j60;..\..\Libraries\uIP-1.0\uip;..\..\Libraries\uIP-1.0\apps\webserver;..\..\User\exti;..\..\User\hc595;..\..\User\output;..\..\User\WDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/input/: bsp_input.c
    ../../User/usart1/: bsp_usart1.c
    ../../User/uIP_enc28j60/: SPI.C bsp_net.c
    ../../User/exti/: bsp_exti.c
    ../../User/hc595/: delay.c hc595.c
    ../../User/output/: io_output.c
    ../../User/WDG/: wdg.c
    ../../User/i2c_ee/: i2c_ee_dma.c
    ../../User/dht11/: bsp_dht11.c
    ../../User/timer3/: timer3.c
  group DOC
    ../../Doc/: readme.txt
  group uIP-1.0
    ../../Libraries/uIP-1.0/uip/: psock.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c
  group uIP_APP
    ../../User/uIP_APP/: tcp_demo.c udp_demo.c
    ../../User/uIP_enc28j60/: emc28j60_uip.c ENC28J60.C
